# Autodesk Inventor assembly: SP011013-1 MAIN ASSY
## iProperties
Created: 2013-01
Part Number: SP011013-1 MAIN ASSY
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
